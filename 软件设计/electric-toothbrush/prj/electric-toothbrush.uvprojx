# Keil uVision project electric-toothbrush.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: electric-toothbrush
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c include: ..\src\APP;..\src\CMSIS;..\src\Device;..\src\HAL_Driver\Src;..\src\HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group MAIN
    ../src/APP/: main.c
  group CORE
    ../src/Device/: Startup_ACM32F0x0.s System_ACM32F0x0.c
  group HAL_Lib
    ../src/HAL_Driver/Src/: HAL_CRC.c HAL_GPIO.c HAL_UART.c HAL_TIMER.c HAL_EFLASH.c HAL_EFlash_EX.lib HAL_DMA.c HAL_ADC.c HAL_EXTI.c
  group HARDWARE
    ../src/APP/: port.c timer.c adc.c flash.c ble.c IIC_Sim.c inertial_chip.c
  group APP
    ../src/APP/: app.c ble_app.c motor_app.c malloc.c led_app.c
  group README
    ./: readme.txt
